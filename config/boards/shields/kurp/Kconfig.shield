## config/boards/shields/kurp/Kconfig.shield
```kconfig
# Copyright (c) 2023 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_KURP
    def_bool $(shields_list_contains,kurp)
```
